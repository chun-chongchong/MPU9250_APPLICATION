# Keil uVision project usart_ts.uvproj, settings and files
target usart_ts (ARM-ADS)
  device: STM32F072RB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: usart_ts +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\..\Lib\common\inc;..\..\Lib\Cortex_Include;..\..\User\usart_ts_user
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group usart_ts
    ../../startup/: startup_stm32f072.s
  group STM32F072B_DISCOVERY
    ../../User/usart_ts_user/: stm32f072b_discovery.c
  group STM32F0xx_StdPeriph_Driver
    ../../Lib/common/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group usart_ts_user
    ../../User/usart_ts_user/: main.c bsp_usrat.c gpio_simulate_usart.c stm32f0xx_it.c
    ../../User/: system_stm32f0xx.c
