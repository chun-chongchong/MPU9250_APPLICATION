# Keil uVision project i2c.uvproj, settings and files
target I2C (ARM-ADS)
  device: STM32F072RB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: i2c +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: .\I2C;..\..\Lib\common\inc;..\..\Lib\Cortex_Include;.\soft_I2C
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group startup
    ../../startup/: startup_stm32f072.s
  group STM32F072B_DISCOVERY
    ./I2C/: stm32f072b_discovery.c
  group STM32F0xx_StdPeriph_Driver
    ../../Lib/common/src/: stm32f0xx_usart.c stm32f0xx_rcc.c stm32f0xx_i2c.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_flash.c
  group I2C
    ./I2C/: stm32f0xx_it.c system_stm32f0xx.c main.c bsp_usart.c delay.c MPU9250.c i2c.c
  group SoftIIC
    ./soft_I2C/: soft_i2c.c
